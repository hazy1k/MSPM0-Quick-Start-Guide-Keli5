# Keil uVision project DMA.uvprojx, settings and files
target DMA (6190000::V6.19::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: __MSPM0G3507__
  c include: ..\Source\third_party\CMSIS\Core\Include;..\Source;..\User;..\Project;..\User\LED;..\User\SysTick;..\User\Uart;..\User\ADC;..\User\DMA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../Source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../Source/ti/driverlib/m0p/: dl_interrupt.c
    ../Source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0g1x0x_g3x0x.h
  group Start
    ../Source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
  group User
    ../User/: main.c ti_msp_dl_config.c ti_msp_dl_config.h
    ../User/LED/: LED.c
    ../User/SysTick/: SysTick.c
    ../User/Uart/: Uart.c
    ../User/ADC/: ADC.c
    ../User/DMA/: DMA.c
